#include <assert.h>
#include <stdio.h>
#include <string.h>
#include "../main/voice_input.c"
#include "../main/button_dispatch.h"

static int64_t clock_us=1000000;
static bool incoming, capture_on, done, fail_send;
static uint8_t rx[512], tx[128][900];
static size_t rx_len, tx_len[128], pcm_bytes;
static unsigned sent, cancel_count;
static struct sockaddr_in source;
int64_t esp_timer_get_time(void){return clock_us;}
int voice_test_socket(int d,int t,int p){(void)d;(void)t;(void)p;return 9;}
int voice_test_bind(int f,const struct sockaddr*a,socklen_t l){(void)f;(void)a;(void)l;return 0;}
int voice_test_fcntl(int f,int cmd,...){(void)f;(void)cmd;return 0;}
int voice_test_close(int f){(void)f;return 0;}
ssize_t voice_test_sendto(int f,const void*d,size_t n,int flags,const struct sockaddr*a,socklen_t l){
    (void)f;(void)flags;(void)a;(void)l;
    if(fail_send)return -1;
    assert(sent<128 && n<=900);memcpy(tx[sent],d,n);tx_len[sent++]=n;return (ssize_t)n;
}
ssize_t voice_test_recvfrom(int f,void*d,size_t n,int flags,struct sockaddr*a,socklen_t*l){
    (void)f;(void)flags;if(!incoming)return -1;
    assert(rx_len<=n);memcpy(d,rx,rx_len);memcpy(a,&source,sizeof(source));*l=sizeof(source);
    incoming=false;return (ssize_t)rx_len;
}
void passport_audio_cancel(void){cancel_count++;capture_on=false;done=false;pcm_bytes=0;}
bool passport_audio_record(void){capture_on=true;done=false;return true;}
void passport_audio_stop_record(void){capture_on=false;done=true;}
bool passport_audio_capture(uint8_t *d,size_t*n){
    if(!pcm_bytes)return false;*n=pcm_bytes>1024?1024:pcm_bytes;memset(d,0,*n);pcm_bytes-=*n;return true;
}
passport_audio_status_t passport_audio_status(void){return (passport_audio_status_t){.recording=capture_on,.record_done=done};}
static void receive(uint8_t type,const char*body,const char*ip){
    source=(struct sockaddr_in){.sin_family=AF_INET,.sin_port=htons(33333)};
    inet_pton(AF_INET,ip,&source.sin_addr);rx[0]=type;rx_len=1+strlen(body);
    memcpy(rx+1,body,rx_len-1);incoming=true;voice_input_tick(true);
}
static void beacon(const char*ip){receive(3,"{\"v\":1,\"role\":\"pc\",\"port\":33333}",ip);}
static bool has_event(const char*name){
    for(unsigned i=0;i<sent;i++)if(tx[i][0]==2 && strstr((char*)tx[i]+1,name))return true;return false;
}
static void dispatch_up(bsp_btn_ev_t event){
    assert(passport_button_should_queue(BSP_BTN_UP,event,true));
    if(event==BSP_BTN_PRESS)voice_input_press();
    if(event==BSP_BTN_RELEASE)voice_input_release();
}
int main(void){
    assert(!passport_button_should_queue(BSP_BTN_UP,BSP_BTN_PRESS,false));
    assert(passport_button_should_queue(BSP_BTN_OK,BSP_BTN_PRESS,false));
    assert(passport_button_should_queue(BSP_BTN_DOWN,BSP_BTN_PRESS,true));
    /* Golden bytes generated by upstream windows/adpcm.py at pinned revision. */
    int16_t vector[1600]; uint8_t encoded[804]; adpcm_state_t codec;
    for(unsigned i=0;i<1600;i++)vector[i]=(int16_t)((i*97)%60000-30000);
    const uint8_t golden[]={0xd0,0x8a,0x00,0x00,0x77,0x77,0x16,0x11,
        0x21,0x22,0x22,0x33,0x34,0x43,0x42,0x32,0x43,0x33,0x43,0x43,
        0x33,0x43,0x43,0x33,0x24,0x24,0x33,0x34,0x33,0x34,0x34,0x33};
    adpcm_state_reset(&codec);
    assert(adpcm_encode_block(&codec,vector,1600,encoded,sizeof(encoded))==804);
    assert(!memcmp(encoded,golden,sizeof(golden)));
    assert(voice_input_open());
    receive(3,"{}","192.168.1.2");assert(!state.candidate);
    receive(4,"","192.168.1.2");assert(!state.candidate);
    voice_input_press();assert(!capture_on && sent==0);
    beacon("192.168.1.2");assert(state.candidate && !state.selected && sent==0);
    assert(voice_input_select());assert(has_event("device.hello"));
    beacon("192.168.1.3");assert(!strcmp(state.peer,"192.168.1.2"));
    dispatch_up(BSP_BTN_PRESS);assert(capture_on && has_event("voice.start"));
    unsigned before=sent;voice_input_press();assert(sent==before);
    voice_input_enter_key();assert(!has_event("key.action"));
    pcm_bytes=3200;voice_input_tick(true);assert(state.blocks==1);
    unsigned audio_index=0;
    for(unsigned i=0;i<sent;i++)if(tx[i][0]==1){
        assert(tx_len[i]==807 && tx[i][1]==0 && tx[i][2]==0x80);audio_index=i;
    }
    assert(audio_index);
    int16_t decoded[1600];assert(adpcm_decode_block(tx[audio_index]+3,804,1600,decoded,1600)==1600);
    for(unsigned i=0;i<1600;i++)assert(decoded[i]==0);
    pcm_bytes=200;dispatch_up(BSP_BTN_RELEASE);assert(state.draining);
    voice_input_tick(true);assert(!state.draining && state.blocks==2 && has_event("voice.end"));
    before=sent;voice_input_enter_key();voice_input_enter_key();assert(sent==before+1);
    assert(has_event("key.action"));
    voice_input_press();before=cancel_count;voice_input_close();assert(cancel_count==before+1);
    assert(!state.opened && !capture_on);
    assert(voice_input_open());beacon("192.168.1.2");assert(voice_input_select());voice_input_press();
    clock_us+=3000001;voice_input_tick(true);assert(!capture_on && !state.selected && !state.candidate);
    beacon("192.168.1.3");voice_input_press();assert(!capture_on); /* reconnect requires OK */
    assert(voice_input_select());voice_input_press();voice_input_tick(false);
    assert(!capture_on && !state.selected);
    beacon("192.168.1.3");assert(voice_input_select());fail_send=true;
    voice_input_press();assert(state.error && !capture_on);fail_send=false;
    voice_input_press();voice_input_release();done=false;
    clock_us+=500001;voice_input_tick(true);
    assert(state.error && !state.draining && !capture_on);
    voice_input_press();clock_us+=60000001;beacon("192.168.1.3");
    assert(!capture_on && !state.recording && !state.draining); /* max duration */
    voice_input_close();voice_input_close();
    puts("PASS: explicit PC selection, peer pinning, ADPCM framing, tail flush, fresh reconnect, bounded stop, exit/offline cancellation and Enter debounce");
}
